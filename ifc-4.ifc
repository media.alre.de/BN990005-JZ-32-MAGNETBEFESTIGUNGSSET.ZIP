Properties of the parts of a building model (IFC4)

# File
Description: Magnetbefestigungsset für Klemmenleisten VOOPL-216.176/VOOPL-318.178 und Funk-Mehrkanalempfänger HTFRL-214.240/HTFRL-316.225, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: BN990005, Magnetbefestigungsset für Klemmenleisten VOOPL-216.176/VOOPL-318.178 und Funk-Mehrkanalempfänger HTFRL-214.240/HTFRL-316.225
In: Raum
Description: Magnetbefestigungsset zur einfachen und sicheren Befestigung der Klemmenleisten VOOPL-216.176 / VOOPL-318.178 und Funk-Mehrkanalempfänger HTFRL-214.240/HTFRL-316.225 auf metallischen Untergrund (z. B. Heizkreisverteiler); Classification: EC001231 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: BN990005; ModelLabel: JZ-32; GlobalTradeItemNumber: 4050528075055; ProductURL: https://alre.de/produkt_BN990005
Pset_Specification - NominalLength: 0.016 m; NominalWidth: 0.016 m; NominalDepth: 0.0115 m; NetWeight: 0.03
Pset_ALRE_ETIM_Properties - Ausführung: Montagehilfe; Länge: 16; ETIM-Klasse: EC001231; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-BN990005.pdf
